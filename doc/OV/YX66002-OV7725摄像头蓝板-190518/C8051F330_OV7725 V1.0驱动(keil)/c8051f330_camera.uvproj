# Keil uVision project c8051f330_camera.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F330 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(25000000)
  output: c8051f330_camera
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./: STARTUP.A51
    ./source/: c8051f330_camera.c
